# Repository tominabox1/BLe-Chiffre

File README.md:

# BLe Chiffre
Repo for the wireless, low profile incarnation of the Le Chiffre keyboard. (you can say it like "Blue Shiff")

The files in this repo do not come with any impied or actual warranty or guarantees. Verify everything before spending a lot of money on ordering PCBs. 

The coin cell battery can be purchased here: https://amzn.to/3ALQ7fF Alternatives in other countries are unknown. 

**DO NOT USE NON-RECHARGABLE BATTERIES**

Special thanks to whydobearsexplod for the great backside silk and to the 40s community as a whole for enjoying my work and keeping me on my toes. The real end game are the friends we've make along the way. 
## Build tips
The board is meant to be used caseless. I suggest you trim all of the switch pins and make nice round solder joints to make the bottom as smooth as possible. Then use rubber bumpers or feet tall enough to keep the board off the surface of your table. 

## Firmware and Bootloader
The bootloader must be flashed to the Holyiot module before use. The modules come without one. The 4 pins under the controller are for flashing the bootloader, refer to the pcb in kicad for the pin arrangement. 

The firmware is available in my ZMK-Config repo: https://github.com/tominabox1/zmk-config2/tree/ble_chiffre/config  Fork my repo from there and modify the keymap to your needs, and utilize the GitHub actions to build new firmware. Refer to the ZMK Discord for any more detailed help. https://zmk.dev/community/discord/invite

## BOM
I have had JLC build this but all the parts are not in LCSC. AllPCB has also built this and they did not have any issues with sourcing the parts. Holyiot aliexpress store can ship modules directly to AllPCB (and presumably other fabs), just message them before ordering. There's probably in-country alternatives for many of these parts from Digikey but I have not looked for them. 

| Description                                                                                                | Part                                                  | References                                                                                                                     | Value                   | Footprint                  | Quantity Per PCB | Datasheet                                                                                                |
|------------------------------------------------------------------------------------------------------------|-------------------------------------------------------|--------------------------------------------------------------------------------------------------------------------------------|-------------------------|----------------------------|------------------|----------------------------------------------------------------------------------------------------------|
|                                                                                                            | BAT-HLD-001-THM-BAT-HLD-001-THM                       | BT1                                                                                                                            | BAT-HLD-001-THM         | BAT_BAT-HLD-001-THM        | 1                | https://www.digikey.com/en/products/detail/linx-technologies-inc/BAT-HLD-001-THM/3044009                 |
| Unpolarized capacitor, small symbol                                                                        | C_Small                                               | C1                                                                                                                             | 4.7nF                   | C_0603_1608Metric          | 1                | ~                                                                                                        |
| Unpolarized capacitor, small symbol                                                                        | C_Small                                               | C2 C3 C4                                                                                                                       | 10uF                    | C_0603_1608Metric          | 3                | ~                                                                                                        |
| 40V 1A Schottky Barrier Rectifier Diode, DO-41                                                             | 1N5819                                                | D35                                                                                                                            | 1N5819                  | D_SOD-123                  | 1                | https://www.lcsc.com/product-detail/Schottky-Barrier-Diodes-SBD_TWGMC-1N5819W_C727115.html               |
| Light emitting diode, small symbol                                                                         | LED_Small                                             | D36                                                                                                                            | Orange                  | LED_0603_1608Metric        | 1                | ~                                                                                                        |
| Diode, small symbol                                                                                        | D_Small                                               | D1 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 D20 D21 D22 D23 D24 D25 D26 D27 D28 D29 D30 D31 D32 D33 D34 | D_Small                 | D_SOD-123                  | 34               | ~                                                                                                        |
|                                                                                                            | USB_C_Receptacle_USB2.0-Connector-LeChiffreBLE-rescue | J1                                                                                                                             | USB_C_Receptacle_USB2.0 | HRO_TYPE-C-31-M-12         | 1                | https://www.lcsc.com/product-detail/USB-Connectors_Korean-Hroparts-Elec-TYPE-C-31-M-12_C165948.html      |
| P-MOSFET transistor, source/gate/drain                                                                     | Q_PMOS_SGD                                            | Q1 Q2                                                                                                                          | AP3407                  | SOT-23                     | 2                | https://www.lcsc.com/product-detail/MOSFETs_ALLPOWER-ShenZhen-Quan-Li-Semiconductor-AP3407_C353080.html  |
| Resistor, small symbol                                                                                     | R_Small                                               | R7                                                                                                                             | 1k                      | R_0603_1608Metric          | 1                | ~                                                                                                        |
| Resistor, small symbol                                                                                     | R_Small                                               | R5 R6                                                                                                                          | 2.2k                    | R_0603_1608Metric          | 2                | ~                                                                                                        |
| Resistor, small symbol                                                                                     | R_Small                                               | R8                                                                                                                             | 4.7k                    | R_0603_1608Metric          | 1                | ~                                                                                                        |
| Resistor, small symbol                                                                                     | R_Small                                               | R1 R2                                                                                                                          | 5.1k                    | R_0603_1608Metric          | 2                | ~                                                                                                        |
| Resistor, small symbol                                                                                     | R_Small                                               | R4                                                                                                                             | 100k                    | R_0603_1608Metric          | 1                | ~                                                                                                        |
| Resistor, small symbol                                                                                     | R_Small                                               | R101                                                                                                                           | 806K                    | R_0603_1608Metric          | 1                | ~                                                                                                        |
| Resistor, small symbol                                                                                     | R_Small                                               | R3                                                                                                                             | 1M                      | R_0603_1608Metric          | 1                | ~                                                                                                        |
| Resistor, small symbol                                                                                     | R_Small                                               | R102 R103                                                                                                                      | 2M                      | R_0603_1608Metric          | 2                | ~                                                                                                        |
| Momentary Switch, single pole double throw                                                                 | SW_Push_SPDT                                          | SW1                                                                                                                            | MSK-12C02               | SW_SPDT_PCM12              | 1                | ~                                                                                                        |
| Push button switch, generic, two pins                                                                      | SKQGAFE010                                            | SW2                                                                                                                            | SW_Push                 | SW_SPST_TL3342             | 1                | https://www.mouser.com/ProductDetail/Alps-Alpine/SKQGAFE010?qs=N5Jky1br14NfR%252BVUVAoP9A%3D%3D          |
|                                                                                                            | AP2112K-3.3-Regulator_Linear-LeChiffreBLE-rescue      | U2                                                                                                                             | AP2112K-3.3             | SOT-23-5                   | 1                | https://www.diodes.com/assets/Datasheets/AP2112.pdf                                                      |
| Single cell, Li-Ion/Li-Po charge management controller, 4.20V, Tri-State Status Output, in SOT23-5 package | MCP73831-2-OT                                         | U3                                                                                                                             | MCP73831-2-OT           | SOT-23-5                   | 1                | https://www.lcsc.com/product-detail/Battery-Management-ICs_Microchip-Tech-MCP73831T-2ACI-OT_C424093.html |
| Bluetooth module                                                                                           | 18010                                                 | U101                                                                                                                           | Holyiot 18010           | Module_Extra:Holyiot_18010 | 1                | https://www.aliexpress.com/item/32868002366.html?spm=a2g0s.9042311.0.0.27cf4c4dVFuyIS                    |

## KiCad design KiCad/LeChiffreBLE_Single_Side.kicad_pcb

Parts:
BT1: BAT-HLD-001-THM; BAT_BAT-HLD-001-THM
C1: 4.7nF; C_0603_1608Metric
C2, C3, C4: 10uF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34: D_Small; D_SOD-123
D35: 1N5819; D_SOD-123
D36: Charge; LED_0603_1608Metric
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J101: Conn_01x04_Female; PinHeader_1x04_P2.54mm_Vertical
J102: Conn_01x04_Female; PinHeader_1x04_P2.54mm_Horizontal
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX15, MX16, MX17, MX18, MX19, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX27, MX28, MX29, MX30, MX31, MX32, MX33, MX34: MX-NoLED; Kailh-PG1350-1u-NoLED
Q1, Q2: AP3407; SOT-23
R1, R2: 5.1k; R_0603_1608Metric
R3: 1M; R_0603_1608Metric
R4: 100k; R_0603_1608Metric
R5, R6: 2.2k; R_0603_1608Metric
R7: 1k; R_0603_1608Metric
R8: 4.7k; R_0603_1608Metric
R101: 806K; R_0603_1608Metric
R102, R103: 2M; R_0603_1608Metric
SW1: MSK-12C02; SW_SPDT_PCM12
SW2: SW_Push; SW_SPST_TL3342
U2: AP2112K-3.3; SOT-23-5
U3: MCP73831-2-OT; SOT-23-5
U101: Holyiot_18010

Connections:
BVOLT: R101.1, R102.2, U101.12
CC1: J1.A5 (CC1), R1.1
CC2: J1.B5 (CC2), R2.1
COL0: MX1.1 (COL), MX2.1 (COL), MX3.1 (COL), U101.3
COL1: MX4.1 (COL), MX5.1 (COL), MX6.1 (COL), U101.4
COL2: MX7.1 (COL), MX8.1 (COL), MX9.1 (COL), MX13.1 (COL), U101.5
COL3: MX10.1 (COL), MX11.1 (COL), MX12.1 (COL), U101.6
COL4: MX14.1 (COL), MX15.1 (COL), MX16.1 (COL), MX17.1 (COL), U101.7
COL5: MX18.1 (COL), MX19.1 (COL), MX20.1 (COL), MX21.1 (COL), U101.40
COL6: MX22.1 (COL), MX23.1 (COL), MX24.1 (COL), U101.39
COL7: MX25.1 (COL), MX26.1 (COL), MX27.1 (COL), MX28.1 (COL), U101.36
COL8: MX29.1 (COL), MX30.1 (COL), MX31.1 (COL), U101.35
COL9: MX32.1 (COL), MX33.1 (COL), MX34.1 (COL), U101.34
D+: J1.A6 (D+), J1.B6 (D+), U101.45
D-: J1.A7 (D-), J1.B7 (D-), U101.46
EXT_VCC: J101.2, Q2.3 (D), R5.1, R6.1
Earth: C1.2, J1.S1 (SHIELD), R3.2
GND: BT1.-, BT1.N, C1.1, C2.2, C3.2, C4.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J101.1, J102.1, R1.2, R2.2, R3.1, R4.2, R8.1, R102.1, R103.2, SW2.2, U2.2 (GND), U3.2 (VSS), U101.1, U101.32, U101.44
unnamed: C2.1, D35.1 (K), Q1.1 (S), U2.1 (VIN), U2.3 (EN)
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: D3.2 (A), MX3.2 (ROW)
unnamed: D4.2 (A), MX4.2 (ROW)
unnamed: D5.2 (A), MX5.2 (ROW)
unnamed: D6.2 (A), MX6.2 (ROW)
unnamed: D7.2 (A), MX7.2 (ROW)
unnamed: D8.2 (A), MX8.2 (ROW)
unnamed: D9.2 (A), MX9.2 (ROW)
unnamed: D10.2 (A), MX10.2 (ROW)
unnamed: D11.2 (A), MX11.2 (ROW)
unnamed: D12.2 (A), MX12.2 (ROW)
unnamed: D13.2 (A), MX13.2 (ROW)
unnamed: D14.2 (A), MX14.2 (ROW)
unnamed: D15.2 (A), MX15.2 (ROW)
unnamed: D16.2 (A), MX16.2 (ROW)
unnamed: D17.2 (A), MX17.2 (ROW)
unnamed: D18.2 (A), MX18.2 (ROW)
unnamed: D19.2 (A), MX19.2 (ROW)
unnamed: D20.2 (A), MX20.2 (ROW)
unnamed: D21.2 (A), MX21.2 (ROW)
unnamed: D22.2 (A), MX22.2 (ROW)
unnamed: D23.2 (A), MX23.2 (ROW)
unnamed: D24.2 (A), MX24.2 (ROW)
unnamed: D25.2 (A), MX25.2 (ROW)
unnamed: D26.2 (A), MX26.2 (ROW)
unnamed: D27.2 (A), MX27.2 (ROW)
unnamed: D28.2 (A), MX28.2 (ROW)
unnamed: D29.2 (A), MX29.2 (ROW)
unnamed: D30.2 (A), MX30.2 (ROW)
unnamed: D31.2 (A), MX31.2 (ROW)
unnamed: D32.2 (A), MX32.2 (ROW)
unnamed: D33.2 (A), MX33.2 (ROW)
unnamed: D34.2 (A), MX34.2 (ROW)
unnamed: D36.1 (K), R7.2
unnamed: Q1.3 (D), R101.2, SW1.1 (A)
unnamed: R7.1, U3.1 (STAT)
unnamed: R8.2, U3.5 (PROG)
Power_Pin: Q2.2 (G), R103.1, U101.54
RESET: SW2.1, U101.48
ROW0: D1.1 (K), D4.1 (K), D7.1 (K), D10.1 (K), D14.1 (K), U101.2
ROW1: D2.1 (K), D5.1 (K), D8.1 (K), D11.1 (K), D15.1 (K), U101.8
ROW2: D3.1 (K), D6.1 (K), D9.1 (K), D12.1 (K), D16.1 (K), U101.9
ROW3: D13.1 (K), D17.1 (K), U101.10
ROW4: D18.1 (K), D22.1 (K), D26.1 (K), D29.1 (K), D32.1 (K), U101.33
ROW5: D19.1 (K), D23.1 (K), D27.1 (K), D30.1 (K), D33.1 (K), U101.41
ROW6: D20.1 (K), D24.1 (K), D28.1 (K), D31.1 (K), D34.1 (K), U101.42
ROW7: D21.1 (K), D25.1 (K), U101.43
SCL: J101.3, R5.2, U101.49
SDA: J101.4, R6.2, U101.50
SWC: J102.3, U101.37
SWD: J102.4, U101.38
VBAT: BT1.+@1, BT1.+@2, BT1.+@3, BT1.+@4, C4.1, SW1.2 (B), U3.3 (VBAT)
VBUS: D35.2 (A), D36.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J102.2, Q1.2 (G), R4.1, U3.4 (VDD), U101.47
VDD_NRF: C3.1, Q2.1 (S), U2.5 (VOUT), U101.55

Board: 2 copper layers, 244.1 x 89.7 mm, 96 parts (0 on the bottom side), 74 nets.

File Fab Files/Ble Chiffre BOM.csv:

Description,Part,References,Value,Footprint,Quantity Per PCB,Datasheet
,BAT-HLD-001-THM-BAT-HLD-001-THM,BT1,BAT-HLD-001-THM,BAT_BAT-HLD-001-THM,1,https://www.digikey.com/en/products/detail/linx-technologies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
"Unpolarized capacitor, small symbol",C_Small,C1,4.7nF,C_0603_1608Metric,1,~
"Unpolarized capacitor, small symbol",C_Small,C2 C3 C4,10uF,C_0603_1608Metric,3,~
"40V 1A Schottky Barrier Rectifier Diode, DO-41",1N5819,D35,1N5819,D_SOD-123,1,https://www.lcsc.com/product-detail/Schottky-Barrier-Diodes-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
"Light emitting diode, small symbol",LED_Small,D36,Orange,LED_0603_1608Metric,1,~
"Diode, small symbol",D_Small,D1 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 D20 D21 D22 D23 D24 D25 D26 D27 D28 D29 D30 D31 D32 D33 D34,D_Small,D_SOD-123,34,~
,USB_C_Receptacle_USB2.0-Connector-LeChiffreBLE-rescue,J1,USB_C_Receptacle_USB2.0,HRO_TYPE-C-31-M-12,1,https://www.lcsc.com/product-detail/USB-Connectors_Korean-Hr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
"P-MOSFET transistor, source/gate/drain",Q_PMOS_SGD,Q1 Q2,AP3407,SOT-23,2,https://www.lcsc.com/product-detail/MOSFETs_ALLPOWER-ShenZhe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
"Resistor, small symbol",R_Small,R7,1k,R_0603_1608Metric,1,~
"Resistor, small symbol",R_Small,R5 R6,2.2k,R_0603_1608Metric,2,~
"Resistor, small symbol",R_Small,R8,4.7k,R_0603_1608Metric,1,~
"Resistor, small symbol",R_Small,R1 R2,5.1k,R_0603_1608Metric,2,~
"Resistor, small symbol",R_Small,R4,100k,R_0603_1608Metric,1,~
"Resistor, small symbol",R_Small,R101,806K,R_0603_1608Metric,1,~
"Resistor, small symbol",R_Small,R3,1M,R_0603_1608Metric,1,~
"Resistor, small symbol",R_Small,R102 R103,2M,R_0603_1608Metric,2,~
"Momentary Switch, single pole double throw",SW_Push_SPDT,SW1,MSK-12C02,SW_SPDT_PCM12,1,~
"Push button switch, generic, two pins",SKQGAFE010,SW2,SW_Push,SW_SPST_TL3342,1,https://www.mouser.com/ProductDetail/Alps-Alpine/SKQGAFE010?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
,AP2112K-3.3-Regulator_Linear-LeChiffreBLE-rescue,U2,AP2112K-3.3,SOT-23-5,1,https://www.diodes.com/assets/Datasheets/AP2112.pdf
"Single cell, Li-Ion/Li-Po charge management controller, 4.20V, Tri-State Status Output, in SOT23-5 package",MCP73831-2-OT,U3,MCP73831-2-OT,SOT-23-5,1,https://www.lcsc.com/product-detail/Battery-Management-ICs_M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
Bluetooth module,18010,U101,Holyiot 18010,Module_Extra:Holyiot_18010,1,https://www.aliexpress.com/item/32868002366.html?spm=a2g0s.9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

## Commit log

2022-01-13 Add case
